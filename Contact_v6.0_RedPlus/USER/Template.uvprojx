# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\GPIO;..\HARDWARE\MOTOR;..\HARDWARE\PWM;..\HARDWARE\LED;..\HARDWARE\EXTI;..\HARDWARE\TIMER;..\HARDWARE\KEY;..\HARDWARE\USART3;..\HARDWARE\BinaryToHex;..\HARDWARE\PROCEDURE;..\HARDWARE\PRO_SUPPORT;..\HARDWARE\PRO_BUFF
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: stm32f4xx_it.c system_stm32f4xx.c main.c
  group FWLIB
    ../FWLIB/src/: stm32f4xx_wwdg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_sai.c stm32f4xx_rtc.c stm32f4xx_rng.c stm32f4xx_rcc.c stm32f4xx_pwr.c stm32f4xx_ltdc.c stm32f4xx_iwdg.c stm32f4xx_i2c.c stm32f4xx_hash_sha1.c stm32f4xx_hash_md5.c stm32f4xx_hash.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_flash_ramfunc.c stm32f4xx_flash.c stm32f4xx_exti.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_dcmi.c stm32f4xx_dbgmcu.c stm32f4xx_dac.c stm32f4xx_cryp_tdes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_aes.c stm32f4xx_cryp.c stm32f4xx_crc.c stm32f4xx_can.c stm32f4xx_adc.c misc.c
  group HARDWARE
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/GPIO/: gpio.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/PROCEDURE/: procedure.c
    ../HARDWARE/PRO_SUPPORT/: pro_support.c
    ../HARDWARE/PRO_BUFF/: pro_buff.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
